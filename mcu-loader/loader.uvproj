# Keil uVision project loader.uvproj, settings and files
target loader (ARM-ADS)
  device: LPC1343 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: loader +hex
  AfterMake: .\hex2bin.exe -s 0x00008000 -b 0x00000000 -o loader.bin ".\.out\loader.hex"
  AfterMake: .\makecrc.exe CORTEX loader.bin
  c flags: Optim=3
  c define: CORTEX SUBST_SMALL
  c include: ../libs
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\loader.sct
  group main
    ./: startup_LPC13xx.s main.c usbdesc.c system_LPC13xx.c iap.c loader.sct gio_lpc13xx.c
    ../libs/: crc.c gost.c
