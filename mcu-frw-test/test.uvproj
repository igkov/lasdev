# Keil uVision project test.uvproj, settings and files
target test (ARM-ADS)
  device: LPC1343 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: test +hex
  AfterMake: .\hex2bin.exe -s 0x00007000 -b 0x00001000 -o test.bin ".\.out\test.hex"
  AfterMake: .\makecrc.exe CORTEX test.bin
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\linker.sct
  group main
    ./: startup_LPC13xx.s main.c gio_lpc13xx.c leds.c linker.sct
