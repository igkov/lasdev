# Keil uVision project USBCDC.uvproj, settings and files
target CDC (ARM-ADS)
  device: LPC1343 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: USBCDC +hex
  AfterMake: .\hex2bin.exe -s 0x00008000 -b 0x00000000 -o usbcdc.bin ".\.out\usbcdc.hex"
  AfterMake: .\makecrc.exe CORTEX usbcdc.bin
  c flags: Optim=3
  c define: CORTEX
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\USBCDC.sct
  group main
    ./: startup_LPC13xx.s main.c
  group libs
    ./: fifo.c uart.c core_cm3.c system_LPC13xx.c gio_lpc13xx.c
  group usb
    ./: cdcuser.c usbcore.c usbdesc.c usbhw_LPC13xx.c usbuser.c
