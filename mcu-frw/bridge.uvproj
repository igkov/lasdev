# Keil uVision project bridge.uvproj, settings and files
target LaserModFRW (dbg) (ARM-ADS)
  device: LPC1343 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: laserfrw +hex
  AfterMake: .\hex2bin.exe -s 0x00008000 -b 0x00000000 -o laserfrw.bin ".\.out\laserfrw.hex"
  AfterMake: .\makecrc.exe CORTEX laserfrw.bin
  c flags: Optim=3
  c define: CORTEX _LPC1300_
  c include: ./;../libs
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\linker.sct
  group Source Group 1
    ./: startup_LPC13xx.s main.c system_LPC13xx.c usbdesc.c linker.sct linker_rel.sct
  group libs
    ./: event.c i2c.c gio_lpc13xx.c leds.c lsm303.c spi.c spi_eeprom.c uart.c iap.c uni_t_proto.c spi9.c
    ../libs/: rev.c crc.c solve.c vector.c orientation.c lowpass.c calibrate.c lcd.c
target LaserModFRW (rel) (ARM-ADS)
  device: LPC1343 NXP (founded by Philips)
  cpu: as above
  output: laserfrw_rel +hex
  AfterMake: .\hex2bin.exe -s 0x00007000 -b 0x00001000 -o laserfrw_rel.bin ".\.out_rel\laserfrw_rel.hex"
  c flags: Optim=3
  c define: CORTEX _LPC1300_ RELEASE
  c include: ./;../libs
  asm define: RELEASE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\linker_rel.sct
target LaserModFRW (bluetooth) (ARM-ADS)
  device: LPC1343 NXP (founded by Philips)
  cpu: as above
  output: laserfrw +hex
  AfterMake: as above
  AfterMake: .\makecrc.exe CORTEX laserfrw.bin
  c flags: Optim=3
  c define: CORTEX _LPC1300_ BLUETOOTH
  c include: ./;../libs
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\linker.sct
